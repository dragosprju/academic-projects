# Keil uVision project Masinuta2.uvprojx, settings and files
target Masinuta2 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Masinuta2
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KL25Z -D__CORTEX_M0PLUS -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_SLEEP=1 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_SPISLAVE=1 -DTARGET_KLXX -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DTARGET_LIKE_CORTEX_M0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1479551176.98 -DTARGET_M0P -DDEVICE_SERIAL=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS --cpu=Cortex-M0 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed-rtos; mbed-rtos/rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0P; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0P/TOOLCHAIN_ARM; motorsWrap; motors; sensorWrap; HCSR04; sensor; leds; bluetoothWrap; DRV8833_edited; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM0PLUS,-D__CORTEX_M0PLUS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  group DRV8833_edited
    DRV8833_edited/: DRV8833.cpp DRV8833.h
  group HCSR04
    HCSR04/: HCSR04.cpp HCSR04.h
  group Masinuta2
    ./: main.cpp mbed_config.h settings.h
  group TARGET_CORTEX_M
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
  group TARGET_KL25Z
    mbed/TARGET_KL25Z/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
  group TARGET_KLXX
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0P/TOOLCHAIN_ARM/: HAL_CM0.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MKL25Z4.o sys.o system_MKL25Z4.o
  group bluetoothWrap
    bluetoothWrap/: bluetoothWrap.cpp bluetoothWrap.h
  group leds
    leds/: leds.cpp leds.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group motors
    motors/: motors.cpp motors.h
  group motorsWrap
    motorsWrap/: motorsWrap.cpp motorsWrap.h
  group rtos
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group sensor
    sensor/: sensor.cpp sensor.h
  group sensorWrap
    sensorWrap/: sensorWrap.cpp sensorWrap.h
